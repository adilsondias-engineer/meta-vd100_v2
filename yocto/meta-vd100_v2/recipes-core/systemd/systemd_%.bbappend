PACKAGECONFIG:append = " timesyncd"
PACKAGECONFIG:append = " networkd"
