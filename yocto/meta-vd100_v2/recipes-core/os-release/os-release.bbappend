OS_RELEASE_FIELDS:prepend = " HOME_URL SUPPORT_URL BUG_REPORT_URL"
HOME_URL = "https://github.com/adilsondias-engineer/versal-ai-edge-vd100-linux"
SUPPORT_URL = "https://github.com/adilsondias-engineer/versal-ai-edge-vd100-linux"
BUG_REPORT_URL = "https://github.com/adilsondias-engineer/versal-ai-edge-vd100-linux"